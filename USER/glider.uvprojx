# Keil uVision project glider.uvprojx, settings and files
target glider (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: glider +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS,ARM_MATH_CM4,_CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__DEBUG,__FPU_PRESENT
  c include: ..\CORE;..\USER;..\FWLIB\inc;..\HardwareDriver\delay;..\HardwareDriver\sys;..\HardwareDriver\usart;..\HardwareDriver\AHRS;..\HardwareDriver\MasSla_Comm;..\HardwareDriver\altimeter;..\HardwareDriver\SD;..\HardwareDriver\USB\STM32_USB_HOST_Library\Class\MSC\inc;..\HardwareDriver\USB\STM32_USB_HOST_Library\Core\inc;..\HardwareDriver\USB\STM32_USB_OTG_Driver\inc;..\HardwareDriver\USB\USB_APP;..\HardwareDriver\CTD48M;..\HardwareDriver\WK2124;..\HardwareDriver\sonar;..\HardwareDriver\BD_RNSS;..\HardwareDriver\BD_RDSS;..\HardwareDriver\LED;..\HardwareDriver\WDG;..\HardwareDriver\RTC;..\HardwareDriver\RF;..\Include;..\FATFS\exfuns;..\FATFS\src;..\RT-Thread\inc;..\RT-Thread\libc;.\TestProgram;..\Application;..\Application\MS_Com_Process;..\Application\CRC8;..\Application\Upper_Comm_Process;..\Application\Info_Record;..\DSP_Lib\Include;..\Application\Power_Control;..\Application\Navigation
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\OBJ\LED.sct
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
    ./TestProgram/: test.c
    ../Application/: struct.h
  group HardwareDriver
    ../HardwareDriver/AHRS/: AHRS.c
    ../HardwareDriver/altimeter/: altimeter.c
    ../HardwareDriver/CTD48M/: CTD48M.c
    ../HardwareDriver/delay/: delay.c
    ../HardwareDriver/MasSla_Comm/: MS_Comm.c
    ../HardwareDriver/SD/: SD.c
    ../HardwareDriver/usart/: print_uart.c
    ../HardwareDriver/WK2124/: WK2124.c
    ../HardwareDriver/sonar/: sonar.c
    ../HardwareDriver/BD_RNSS/: BD_RNSS.c
    ../HardwareDriver/BD_RDSS/: BD_RDSS.c
    ../HardwareDriver/LED/: led.c
    ../HardwareDriver/WDG/: wdg.c
    ../HardwareDriver/RTC/: RTC.c
    ../HardwareDriver/RF/: RF.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_spi.c stm32f4xx_sdio.c stm32f4xx_exti.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_can.c
  group USB_OTG
    ../HardwareDriver/USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group USB_HOST
    ../HardwareDriver/USB/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
    ../HardwareDriver/USB/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group USB_APP
    ../HardwareDriver/USB/USB_APP/: usb_bsp.c usbh_usr.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/src/option/: cc936.c
    ../FATFS/exfuns/: exfuns.c fattester.c
  group RT-Thread
    ../RT-Thread/src/: clock.c components.c context_rvds.S cpuport.c device.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler.c thread.c timer.c board.c
    ../RT-Thread/inc/: rtconfig.h
  group Application
    ../Application/MS_Com_Process/: MS_Com_Process.c
    ../Application/CRC8/: CRC8.c
    ../Application/Upper_Comm_Process/: Upper_Comm.c
    ../Application/Info_Record/: Info_Record.c
    ../Application/Power_Control/: power_control.c
    ../Application/Navigation/: navigation.c
  group DSP_Lib
    ../DSP_Lib/FastMathFunctions/: arm_cos_f32.c arm_sin_f32.c
target gliser_DEBUG (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: as above
  output: glider +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS,ARM_MATH_CM4,_CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__DEBUG
  c include: ..\CORE;..\USER;..\FWLIB\inc;..\HardwareDriver\delay;..\HardwareDriver\sys;..\HardwareDriver\usart;..\HardwareDriver\AHRS;..\HardwareDriver\MasSla_Comm;..\HardwareDriver\altimeter;..\HardwareDriver\SD;..\HardwareDriver\USB\STM32_USB_HOST_Library\Class\MSC\inc;..\HardwareDriver\USB\STM32_USB_HOST_Library\Core\inc;..\HardwareDriver\USB\STM32_USB_OTG_Driver\inc;..\HardwareDriver\USB\USB_APP;..\HardwareDriver\CTD48M;..\HardwareDriver\WK2124;..\HardwareDriver\sonar;..\HardwareDriver\BD_RNSS;..\HardwareDriver\BD_RDSS;..\HardwareDriver\LED;..\HardwareDriver\WDG;..\HardwareDriver\RTC;..\HardwareDriver\RF;..\Include;..\FATFS\exfuns;..\FATFS\src;..\RT-Thread\inc;..\RT-Thread\libc;.\TestProgram;..\Application;..\Application\MS_Com_Process;..\Application\CRC8;..\Application\Upper_Comm_Process;..\Application\Info_Record;..\DSP_Lib\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\OBJ\LED.sct
